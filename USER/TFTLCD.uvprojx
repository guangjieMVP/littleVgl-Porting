# Keil uVision project TFTLCD.uvprojx, settings and files
target TFTLCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TFTLCD_MCU +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\lvgl-5.1\lv_core;..\lvgl-5.1\lv_draw;..\lvgl-5.1\lv_hal;..\lvgl-5.1\lv_misc;..\lvgl-5.1\lv_misc\lv_fonts;..\lvgl-5.1\lv_objx;..\lvgl-5.1\lv_themes;..\lvgl-5.1;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\lvgl-5.1\lv_app;..\lvgl-5.1\lv_examples\lv_apps\demo;..\lvgl-5.1\lv_examples;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TIMER/: timer.c
  group lv_app
    ../lvgl-5.1/lv_app/: lv_display.c lv_touchpad.c
  group lv_core
    ../lvgl-5.1/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lv_draw
    ../lvgl-5.1/lv_draw/: lv_draw.c lv_draw_rbasic.c lv_draw_vbasic.c
  group lv_fonts
    ../lvgl-5.1/lv_misc/lv_fonts/: lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group lv_hal
    ../lvgl-5.1/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl-5.1/: lv_conf.h lvgl.h
  group lv_misc
    ../lvgl-5.1/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_trigo.c lv_txt.c lv_ufs.c
  group lv_objx
    ../lvgl-5.1/lv_objx/: lv_bar.c lv_btn.c lv_btnm.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group lv_themes
    ../lvgl-5.1/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_examples
    ../lvgl-5.1/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
  group README
    ../: readme.txt
